# Repository engali94/PAM8301_Circuit

File README.md:

# PAM8301 Breakout Board

This is a  circuit board for the PAM8301 Class-D Mono Audio Amplifier.

## KiCad design pam8301_breakout.kicad_pcb

Parts:
C1, C3: 0.1uF; C_0603_1608Metric
C2: 10uF; C_0603_1608Metric
J1: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J2: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
JP1: Jumper_NC_Small; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
LS1: Speaker; CMT-5023S
R1: 47k; R_0603_1608Metric
U1: PAM8301; SOT-23-6

Connections:
+3V3: C1.1, C2.1, J1.1, U1.5 (VDD)
/IN: C3.2, J1.3
/~SD~: J1.4, U1.4 (~SD)
GND: C1.2, C2.2, J1.2, U1.2 (GND)
unnamed: C3.1, R1.2
unnamed: J2.1, JP1.1, U1.1 (OUT-)
unnamed: J2.2, LS1.1, U1.6 (OUT+)
unnamed: JP1.2, LS1.2
unnamed: R1.1, U1.3 (IN)

Board: 2 copper layers, 20.0 x 11.0 mm, 9 parts (1 on the bottom side), 9 nets.

## Commit log

2019-06-03 First release
2019-06-03 initail
